# Keil uVision project EthernetK64F.uvprojx, settings and files
target K64F (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.3.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EthernetK64F
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\FreeRTOS\include;.\FreeRTOS\portable;.\inc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Sources
    ./src/: main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
